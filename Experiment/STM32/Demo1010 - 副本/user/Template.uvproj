# Keil uVision project Template.uvproj, settings and files
target Template (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  asm include: E:\Desktop\template\driver
  group user
    ./: STARTUP.A51
    E:/Desktop/template/user/: main.c
