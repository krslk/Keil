# Keil uVision project Demo.uvproj, settings and files
target RetroSnaker (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: RetroSnaker +hex
  c flags: Optimize=8 SizeSpeed=1
  group startup
    ./startup/: STARTUP.A51
  group user
    ./user/: main.c
